# IAR project Laser_sen0492.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L151C8 STM8L151C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: HSE_VALUE=11059200
  ICCSTM8.CCIncludePath2: D:\Abdulmalik\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib-master\Libraries\STM8L15x_StdPeriph_Driver\inc; D:\Abdulmalik\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib-master\Project\STM8L15x_StdPeriph_Examples\ADC\ADC_AnalogWatchdog; $PROJ_DIR$; D:\Abdulmalik\STM8L15x-16x-05x-AL31-L_StdPeriph_Lib-master\Libraries\STM8L15x_StdPeriph_Driver\src
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: Laser_sen0492.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    ./: _delay_us.s main.c
    ../../STM8L15x-16x-05x-AL31-L_StdPeriph_Lib-master/Libraries/STM8L15x_StdPeriph_Driver/src/: stm8l15x_adc.c stm8l15x_clk.c stm8l15x_gpio.c stm8l15x_iwdg.c stm8l15x_tim4.c stm8l15x_usart.c
