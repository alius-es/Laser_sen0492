<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\Laser_sen0492.ewp</path>
    </project>
    <batchBuild />
</workspace>
